options:
  parameters:
    generate_options: qt_gui
    id: fmsteroetest
    output_language: python
    title: FM Stereo Test
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    label: FM Channel Frequency
    start: 88e6
    step: 0.1e6
    stop: 107e6
    value: 91.9e6
  states: {}
- name: lmr
  id: variable_qtgui_range
  parameters:
    label: L - R
    start: '0'
    step: '1'
    stop: '300'
    value: '0.5'
  states: {}
- name: lpr
  id: variable_qtgui_range
  parameters:
    label: L + R
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 250e3
  states: {}
- name: analog_pll_freqdet_cf_0
  id: analog_pll_freqdet_cf
  parameters:
    max_freq: 2*math.pi / (samp_rate/19.5e3)
    min_freq: 2*math.pi / (samp_rate/18.5e3)
    w: 2*math.pi/100
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 38e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_1_0
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: 19e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: samp_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: '25000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 19.5e3
    low_cutoff_freq: 18.5e3
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 1e2
    win: window.WIN_BLACKMAN
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 38.5e3
    low_cutoff_freq: 37.5e3
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e2
    win: window.WIN_BLACKMAN
  states: {}
- name: band_pass_filter_0_1
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '10'
    high_cutoff_freq: 53e3
    low_cutoff_freq: 23e3
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 1e2
    win: window.WIN_BLACKMAN
  states: {}
- name: band_pass_filter_0_1_0
  id: band_pass_filter
  parameters:
    gain: '1'
    high_cutoff_freq: 53e3
    interp: '1'
    low_cutoff_freq: '20'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '10'
    win: window.WIN_BLACKMAN
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_add_xx_0_0_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_add_xx_0_0_0_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_1
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: lmr
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: lpr
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.2'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.2'
    type: float
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/abraham/Downloads/organfinale25k.wav
    nchan: '2'
    repeat: 'True'
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 15e3
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 1e3
    win: window.WIN_BLACKMAN
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 15e3
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 1e3
    win: window.WIN_BLACKMAN
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 15e3
    gain: '1'
    interp: '10'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: 1e3
    win: window.WIN_BLACKMAN
  states: {state: disabled}
- name: low_pass_filter_0_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 15e3
    gain: '1'
    interp: '10'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: 1e3
    win: window.WIN_BLACKMAN
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_pll_freqdet_cf_0, '0', blocks_float_to_complex_0_0, '0']
- [analog_sig_source_x_0_1, '0', blocks_multiply_xx_0_0, '1']
- [analog_sig_source_x_0_1_0, '0', blocks_add_xx_0_0_0, '1']
- [analog_wfm_rcv_0, '0', band_pass_filter_0, '0']
- [analog_wfm_rcv_0, '0', band_pass_filter_0_1, '0']
- [analog_wfm_rcv_0, '0', low_pass_filter_0, '0']
- [band_pass_filter_0, '0', blocks_float_to_complex_0, '0']
- [band_pass_filter_0_0, '0', blocks_complex_to_float_0, '0']
- [band_pass_filter_0_1, '0', blocks_multiply_xx_0, '1']
- [band_pass_filter_0_1_0, '0', blocks_float_to_complex_0_1, '0']
- [blocks_add_xx_0, '0', audio_sink_0, '1']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_add_xx_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [blocks_add_xx_0_0, '0', low_pass_filter_0_0_0, '0']
- [blocks_add_xx_0_0_0, '0', blocks_add_xx_0_0_0_0, '1']
- [blocks_add_xx_0_0_0_0, '0', band_pass_filter_0_1_0, '0']
- [blocks_complex_to_float_0, '0', blocks_multiply_xx_0, '0']
- [blocks_float_to_complex_0, '0', analog_pll_freqdet_cf_0, '0']
- [blocks_float_to_complex_0_0, '0', band_pass_filter_0_0, '0']
- [blocks_float_to_complex_0_1, '0', analog_wfm_rcv_0, '0']
- [blocks_float_to_complex_0_1, '0', qtgui_waterfall_sink_x_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0_0, '0', blocks_sub_xx_0, '1']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_sub_xx_0, '0']
- [blocks_multiply_const_vxx_0_0_1, '0', blocks_add_xx_0_0, '0']
- [blocks_multiply_const_vxx_0_0_1, '0', blocks_sub_xx_0_0, '0']
- [blocks_multiply_const_vxx_0_0_1_0, '0', blocks_add_xx_0_0, '1']
- [blocks_multiply_const_vxx_0_0_1_0, '0', blocks_sub_xx_0_0, '1']
- [blocks_multiply_xx_0, '0', low_pass_filter_0_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_add_xx_0_0_0, '0']
- [blocks_sub_xx_0, '0', audio_sink_0, '0']
- [blocks_sub_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_sub_xx_0_0, '0', low_pass_filter_0_0_0_0, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_vxx_0_0_1, '0']
- [blocks_wavfile_source_0, '1', blocks_multiply_const_vxx_0_0_1_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [low_pass_filter_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [low_pass_filter_0_0_0, '0', blocks_add_xx_0_0_0_0, '0']
- [low_pass_filter_0_0_0_0, '0', blocks_multiply_xx_0_0, '0']
- [soapy_rtlsdr_source_0, '0', analog_wfm_rcv_0, '0']

metadata:
  file_format: 1
