options:
  parameters:
    generate_options: qt_gui
    id: sdrtest
    output_language: python
    title: FM Demodulation from Interlieved RAW IQ Samples
  states: {}

blocks:
- name: quad_rate
  id: variable
  parameters:
    value: 250e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 25e3
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: int(quad_rate/samp_rate)
    quad_rate: quad_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: int(samp_rate)
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/abraham/github/medium-technica/sdr-codes/include/wbfm_raw_iq_250k_25k
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    vector_input: 'False'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', analog_wfm_rcv_0, '0']

metadata:
  file_format: 1
