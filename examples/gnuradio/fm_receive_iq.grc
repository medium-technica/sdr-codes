options:
  parameters:
    generate_options: qt_gui
    id: sdrtest
    output_language: python
    title: FM Demodulation from Interlieved RAW IQ Samples
  states: {}

blocks:
- name: quad_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: variable_low_pass_filter_taps_0
  id: variable_low_pass_filter_taps
  parameters:
    gain: '1.0'
    samp_rate: samp_rate
    win: firdes.WIN_HAMMING
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: int(quad_rate/samp_rate)
    quad_rate: quad_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: int(samp_rate)
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/abraham/github/medium-technica/sdr-codes/include/wbfm_raw_iq_2.4M_48k.hex
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    vector_input: 'False'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: samp_rate
    type: ccc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 200e3
    decim: '1'
    gain: '1'
    samp_rate: quad_rate
    type: fir_filter_ccf
    width: 10e3
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate*10
    fc: '0'
    fftsize: '1024'
    type: complex
    update_time: '0.05'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '100'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', low_pass_filter_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']

metadata:
  file_format: 1
