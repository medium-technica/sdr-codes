options:
  parameters:
    generate_options: qt_gui
    id: sdrtest
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: fm_freq
  id: variable_qtgui_range
  parameters:
    label: FM Channel Frequency
    start: 88e6
    step: 100e3
    stop: 108e6
    value: 91.9e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '31250'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '8'
    quad_rate: 250e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: int(samp_rate)
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: fm_freq
    samp_rate: 250e3
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [soapy_rtlsdr_source_0, '0', analog_wfm_rcv_0, '0']

metadata:
  file_format: 1
