options:
  parameters:
    generate_options: qt_gui
    id: sdrtest
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: cut_off
  id: variable_qtgui_range
  parameters:
    label: Audio Filter Cut-Off Frequency
    start: 1e3
    step: 1e3
    stop: samp_rate/2
    value: samp_rate/2
  states: {}
- name: fm_freq
  id: variable_qtgui_range
  parameters:
    label: FM Channel Frequency
    start: 88e6
    step: 100e3
    stop: 108e6
    value: 91.9e6
  states: {}
- name: quad_rate
  id: variable
  parameters:
    value: 250e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 130e3
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: samp_rate
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: blocks_complex_to_interleaved_short_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: '1.0'
    vector_output: 'False'
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/abraham/github/medium-technica/sdr-codes/include/wbfm_raw_iq_2.4M_100k.iq
    type: short
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '32768'
    type: complex
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cut_off
    decim: int(samp_rate/48e3)
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: cut_off/2
    win: window.WIN_BLACKMAN
  states: {state: disabled}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 130e3
    decim: int(quad_rate/samp_rate)
    gain: '1'
    samp_rate: quad_rate
    type: fir_filter_ccf
    width: 10e3
    win: window.WIN_BLACKMAN
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: quad_rate
    fc: '0'
    fftsize: '2048'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: quad_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: quad_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: quad_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {state: disabled}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: fm_freq
    samp_rate: quad_rate
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', low_pass_filter_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_waterfall_sink_x_0_0_0, '0']
- [blocks_complex_to_interleaved_short_0, '0', blocks_file_sink_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_interleaved_short_0, '0']
- [low_pass_filter_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0_0_0_0, '0']
- [low_pass_filter_1, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_1, '0', qtgui_waterfall_sink_x_0_0, '0']
- [soapy_rtlsdr_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [soapy_rtlsdr_source_0, '0', low_pass_filter_1, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
