options:
  parameters:
    generate_options: qt_gui
    id: sdrtest
    output_language: python
    title: FM Demodulation from Interlieved RAW Complex Samples
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '5'
    quad_rate: 250e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: int(samp_rate)
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/abraham/github/medium-technica/sdr-codes/include/fm_radio_raw_complex
    repeat: 'False'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0, '0', analog_wfm_rcv_0, '0']

metadata:
  file_format: 1
